# IAR project stm8l151g6.ewp, settings and files
configuration e32-433t20d-32100-v3.0 (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G6 STM8L151G6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x120
  General.GenHeapSize: 0x120
  ICCSTM8.CCDefines: STM8L151G6; E32_433T20D_32100_V3_0; DEF_CHANNEL_BUSY_RSSI=(0)
  ICCSTM8.CCIncludePath2: ..\src\; ..\src\cpu\stm8l151g6\; ..\src\drv\; ..\src\drv\sx127x\; ..\src\drv\sx127x\sx1278; ..\src\hal\inc\; ..\src\platform\; ..\src\platform\stm8l151g6\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8l151g6.hex
  ILINK.IlinkOutputFile: stm8l151g6.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration e32-433t20d-10012-v6.0 (STM8, debug)
  as the first configuration, except:
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L151G6; E32_433T20D_10012_V6_0; DEF_CHANNEL_BUSY_RSSI=(-80)
  ICCSTM8.CCIncludePath2: ..\src\; ..\src\cpu\stm8l151g6\; ..\src\drv\; ..\src\drv\sx127x\; ..\src\drv\sx127x\sx1278\; ..\src\hal\inc\; ..\src\platform\; ..\src\platform\stm8l151g6\
configuration e32-433t30d-10010-v6.2 (STM8, debug)
  as the first configuration, except:
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L151G6; E32_433T30D_10010_V6_2; DEF_CHANNEL_BUSY_RSSI=(-80)
  ICCSTM8.CCIncludePath2: as above
configuration e45-ttl-1w-10024-v2.0 (STM8, debug)
  as the first configuration, except:
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L151G6; E45_TTL_1W_10024_V2_0; DEF_CHANNEL_BUSY_RSSI=(-80)
  group Project
    ../src/: isoc.c main.c
  group Project/cpu
    ../src/cpu/stm8l151g6/: compiler-def.h cpu.h sdcc-interrupts.h stm8l-hw.c stm8l-hw.h stm8l.h
  group Project/drv
    ../src/drv/: lora.c
  group Project/drv/sx1278
    ../src/drv/: lora-sx1278-drv.c
    ../src/drv/sx127x/sx1278/: sx1278.c
  group Project/drv/sx127x
    ../src/drv/sx127x/: sx127x.c
  group Project/hal
    ../src/hal/src/stm8l151g6/: hal-io.c hal-sx127x.c hal-uart.c
  group Project/platform
    ../src/platform/stm8l151g6/: platform.c
